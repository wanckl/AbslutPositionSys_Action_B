# Keil uVision project Action_B.uvproj, settings and files
target STM32F405 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: STM32F405 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Chip\delay;..\..\Chip\sys;..\..\Chip\usart;..\..\HWLIB\MPU6050\eMPL;..\..\HWLIB\MPU6050;..\..\Chip\iic;..\..\HWLIB\LED;..\..\HWLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: stm32f4xx_it.c main.c
  group HWLIB
    ../../HWLIB/MPU6050/: mpu6050.c
    ../../HWLIB/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../HWLIB/LED/: led.c
    ../../HWLIB/: EXTI.c
  group Chip
    ../../Chip/delay/: delay.c
    ../../Chip/sys/: sys.c
    ../../Chip/usart/: usart.c
    ../../Chip/iic/: iic.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
